# Keil uVision project 0378_Humidity_Controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7251 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x0FFF) CLOCK(24000000)
  output: 0378_Humidity_Controller +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
